# Keil uVision project 04_Software.uvprojx, settings and files
target App2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 04_Software +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/AT24Cxx_Driver/AT24Cxx_Driver;../BSP/W25q/Driver;..\Middlewares\Common;..\Middlewares\Ymodem;..\User\SWC_OTA;..\Middlewares\Third_Party\EasyLogger\inc;..\Middlewares\Third_Party\Segger_RTT\inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8008000 size 0x77fff
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Ymodem
    ../Middlewares/Common/: common.c
    ../Middlewares/Ymodem/: ymodem.c
  group Middlewares/EasyLogger
    ../Middlewares/Third_Party/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_port.c elog_utils.c
  group Middlewares/SEGGER_RTT
    ../Middlewares/Third_Party/Segger_RTT/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Bsp/Atc24c02
    ../BSP/AT24Cxx_Driver/AT24Cxx_Driver/: AT24Cxx_Driver.c iic.c
  group Bsp/w25q
    ../BSP/W25q/Driver/: w25qxx.c W25Qxx_handler.c
  group User/App
    ../User/SWC_OTA/: SWC_OTA.c
software components: CMSIS:CORE 4.3.0
