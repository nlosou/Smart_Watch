# Keil uVision project template.uvprojx, settings and files
target STM32F4x1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\MDK-ARM;..\Core\Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Middlerwares\Segger_RTT\inc;..\Middlerwares\EasyLogger\inc;..\Task\Boot_Manager;..\Bsp\key;..\Bsp\Led;..\Bsp\Usart;..\Middlerwares\Ymodem;..\Bsp\Flash;..\Algo\AES;..\Bsp\W25Qxx;..\Bsp\AT24C02;..\Bsp\AT24Cxx_Driver\AT24Cxx_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ../Core/Src/: main.c tim.c gpio.c stm32f4xx_it.c spi.c
    ../Core/Inc/: stm32f4xx_conf.h
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Bsp/key
    ../Bsp/key/: key.c
  group Bsp/Led
    ../Bsp/Led/: led.c
  group Bsp/Usart
    ../Bsp/Usart/: usart.c
  group Bsp/Flash
    ../Bsp/Flash/: Flash.c
  group Bsp/W25Qxx
    ../Bsp/W25Qxx/: W25Qxx.c W25Qxx_handler.c
  group Bsp/AT24C02
    ../Bsp/AT24Cxx_Driver/AT24Cxx_Driver/: AT24Cxx_Driver.c iic.c
  group Middlerwares/Segger_RTT
    ../Middlerwares/Segger_RTT/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlerwares/Easylogger
    ../Middlerwares/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_port.c elog_utils.c
  group Middlerwares/Ymodem
    ../Middlerwares/Ymodem/: ymodem.c common.c
  group Task/Boot_Manager
    ../Task/Boot_Manager/: boot_manager.c
  group Algo/AES
    ../Algo/AES/: AES.c
software components: CMSIS:CORE 5.6.0
